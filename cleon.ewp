# IAR project cleon.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xldn.h
  General.OGChipSelectMenu: MSP430F5338 MSP430F5338
  General.GStackSize2: 1000
  General.GHeapSize2: 100
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: intro\; sys\; hal\; hal\rtclib\; platform\; fs\; fs\FatFs\; app\; $PROJ_DIR$
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5338.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 160
  General.GHeapSize2: 160
  ICC430.newCCIncludePaths: sys\; hal\driverlib\5xx_6xx\; hal\deprecated\IAR\; hal\inc\; hal\; platform\; $PROJ_DIR$
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  group app
    app/: app_define.h app_log.c app_log.h app_usb.c app_usb.h
  group doc
    doc/: hw_architecture.c intro.c power_consumption.c sw_architecture.c usage.c
  group fs
    fs/: fs_define.h fs_init.c fs_init.h
  group fs/FatFs
    fs/FatFs/: ccsbcs.c diskio.c diskio.h ff.c ff.h ffconf.h integer.h
  group hal
    hal/: hal_adc.c hal_adc.h hal_define.h hal_dma.c hal_dma.h hal_flash.c hal_flash.h hal_gpio.c hal_gpio.h hal_init.c hal_init.h hal_pmm.c hal_pmm.h hal_rtc.c hal_rtc.h hal_spi.c hal_spi.h hal_timer.c hal_timer.h hal_uart.c hal_uart.h hal_ucs.c hal_ucs.h hal_wdt.c hal_wdt.h
  group main
    ./: main.c
  group platform
    platform/: cleon_conf.h
  group sys
    sys/: sys_define.h sys_flash.c sys_flash.h sys_gps.c sys_gps.h sys_init.c sys_init.h sys_mcu.c sys_mcu.h sys_mmc.c sys_mmc.h sys_power.c sys_power.h sys_sensors.c sys_sensors.h sys_usb.c sys_usb.h
